# Keil uVision project SerialSW.uvprojx, settings and files
target SerialSW (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SerialSW
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\StellarisWare;..\..\..\6_VisualStudio2015\Afproto-master\Afproto-master\C;C:\ti\TivaWare_C_Series-2.1.4.178;..\Afproto-master\C
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main
    ./: main_serialsw.c
  group Source
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c adc.h aes.h can.h comp.h cpu.h crc.h debug.h des.h eeprom.h emac.h epi.h flash.h fpu.h gpio.h hibernate.h i2c.h interrupt.h lcd.h mpu.h onewire.h pin_map.h pwm.h qei.h readme.txt rom.h rom_map.h rtos_bindings.h shamd5.h ssi.h sw_crc.h sysctl.h sysexc.h systick.h timer.h uart.h udma.h usb.h watchdog.h
    ../Afproto-master/C/: afproto.h crc16.h afproto.c crc16.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.1
